
SRCREV = "aa5bc16415a6c54b3128bccdf74eae21e3fac449"

#SRC_URI  = "git://git@113.196.136.131:22/qac628/Bchip-non-os;protocol=ssh;branch=master;"
SRC_URI  = "git://github.com/tibbotech/plus1_Bnoos.git;protocol=https;branch=master;"

#SRC_URI += "file://main.c.tst0.patch"

require bnoos.inc
