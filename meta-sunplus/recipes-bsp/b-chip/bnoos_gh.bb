
SRCREV = "32916340c7737b19503460c6c731ec19edfe1773"
SRCREV = "aa5bc16415a6c54b3128bccdf74eae21e3fac449"

SRC_URI  = "git://github.com/tibbotech/plus1_Bnoos.git;protocol=https;branch=master;"
#SRC_URI += "file://main.c.tst0.patch"

require bnoos.inc
