# copy of meta/recipes-bsp/u-boot/u-boot-tools_2021.07.bb with
# -src-gh instead of -common

require u-boot-src-gh.inc
require u-boot-tools.inc
