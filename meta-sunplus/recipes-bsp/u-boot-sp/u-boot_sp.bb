require u-boot-src-sp.inc
require u-boot.inc

#DEPENDS += "bc-native dtc-native"
DEPENDS += "bc-native"
