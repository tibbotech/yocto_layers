XBOOT_CONFIG = "q628_Rev2_SPINAND_defconfig"

require xboot-src.inc
require xboot.inc
