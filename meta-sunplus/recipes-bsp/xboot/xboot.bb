XBOOT_CONFIG ?= "q628_defconfig"

require xboot-src.inc
require xboot.inc
