XBOOT_CONFIG ?= "q628_defconfig"

require xboot-src-sp.inc
require xboot.inc
