DEPENDS:remove = "eudev"
DEPENDS:append = " udev"

PACKAGE_ARCH = "${MACHINE_ARCH}"
