
SRCREV="aaab1b38b1542db081d0c7192c8597d76d7c9362"

require soem.inc
