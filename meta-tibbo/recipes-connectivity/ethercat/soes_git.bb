
SRCREV="10c7f5191f6441bf1fd87133056159dad62b1b1b"

require soes.inc
