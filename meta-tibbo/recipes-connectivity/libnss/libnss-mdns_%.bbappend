
RDEPENDS_${PN} += "systemd"
