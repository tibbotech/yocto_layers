DEPENDS += "libpcre-native"
