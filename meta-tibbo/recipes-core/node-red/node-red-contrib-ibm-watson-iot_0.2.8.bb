DESCRIPTION = "Node-RED IoT IBM Nodes"
HOMEPAGE = "https://www.npmjs.com/package/node-red-contrib-ibm-watson-iot"
LICENSE = "Apache-2.0"

SRC_URI  = "git://github.com/ibm-watson-iot/node-red-contrib-ibm-watson-iot.git;protocol=https;tag=${PV}"

require node-red-module.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=89aea4e17d99a7cacdbeed46a0096b10"
