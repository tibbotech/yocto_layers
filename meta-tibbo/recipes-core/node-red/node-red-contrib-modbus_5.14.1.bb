DESCRIPTION = "Node-RED Contrib ModBus Node"
HOMEPAGE = "https://flows.nodered.org/node/node-red-contrib-modbus"
LICENSE = "BSD-3-Clause"

SRC_URI  = "git://github.com/biancode/node-red-contrib-modbus.git;protocol=https;tag=v${PV}"

require node-red-module.inc

LIC_FILES_CHKSUM = "file://LICENSE;md5=89aea4e17d99a7cacdbeed46a0096b10"
