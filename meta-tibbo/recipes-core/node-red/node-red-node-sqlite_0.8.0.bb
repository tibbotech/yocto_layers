SRCREV="9b487098ae5a0c77350876f366ab8eabc2f8e359"

require node-red-nodes.inc

S = "${WORKDIR}/git/storage/sqlite"
