DESCRIPTION = "Node-RED is a visual tool for wiring the Internet of Things"
HOMEPAGE = "http://nodered.org"

require node-red.inc

SRC_URI[pkg.md5sum] = "bfe3754d85d0cd7347203f0c298c40e6"
SRC_URI[pkg.sha256sum] = "9e566f05247b8edd3de003a9fcac740892d9ef716c5a413267eff1c736801080"
