DESCRIPTION = "Node-RED is a visual tool for wiring the Internet of Things"
HOMEPAGE = "http://nodered.org"

require node-red.inc

SRC_URI[pkg.md5sum] = "d7c75e4d847d79d463d9d9fcbd90bcb9"
SRC_URI[pkg.sha256sum] = "af1cdb8a1d57969e2e83877b90b13b95995a6358d5c64b97dc0a7d220697a14f"
