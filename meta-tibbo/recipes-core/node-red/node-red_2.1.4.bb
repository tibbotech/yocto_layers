
require node-red.inc

SRC_URI[pkg.sha256sum] = "b0febda494e9ad558896076b3bdf4cf582083c8a104fde39d0e67532b78586c8"
