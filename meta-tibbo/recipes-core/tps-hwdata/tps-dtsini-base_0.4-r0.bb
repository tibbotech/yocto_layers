DESCRIPTION = "TPS dts current.ini base definition"

require tps-dtsini.inc
