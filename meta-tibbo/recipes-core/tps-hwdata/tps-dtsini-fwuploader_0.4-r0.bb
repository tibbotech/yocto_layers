DESCRIPTION = "TPS dts current.ini for FWUploader"

require tps-dtsini.inc
