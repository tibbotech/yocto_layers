DESCRIPTION = "TPS dts current.ini for RusElProm"

require tps-dtsini.inc
