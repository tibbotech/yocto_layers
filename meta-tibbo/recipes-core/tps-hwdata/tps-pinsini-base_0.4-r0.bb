DESCRIPTION = "TPPgN pins.ini shared base definition"

require tps-pinsini.inc
