
require tps-pinsini.inc

DESCRIPTION = "TPPgN pins.ini shared base definition"
