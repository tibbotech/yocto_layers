
require tps-pinsini.inc

DESCRIPTION = "DSXE pins.ini shared base definition"
