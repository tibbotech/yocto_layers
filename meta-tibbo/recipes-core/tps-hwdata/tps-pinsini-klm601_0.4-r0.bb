DESCRIPTION = "TPPg1 (am335x) Keytroller pinsini shared definition"

require tps-pinsini.inc
