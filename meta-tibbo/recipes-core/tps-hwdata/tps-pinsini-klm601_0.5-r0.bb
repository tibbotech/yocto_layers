
require tps-pinsini.inc

DESCRIPTION = "TPPg1 (am335x) Keytroller pinsini shared definition"
