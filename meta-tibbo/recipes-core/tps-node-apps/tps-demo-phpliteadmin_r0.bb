require tps-demo-phpliteadmin.inc

SRCREV="${AUTOREV}"
