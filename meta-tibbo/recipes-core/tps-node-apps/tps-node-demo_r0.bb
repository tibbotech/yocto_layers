require tps-node-demo.inc

SRCREV="${AUTOREV}"
