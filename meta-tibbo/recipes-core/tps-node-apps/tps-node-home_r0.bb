require tps-node-home.inc

SRCREV="${AUTOREV}"
