require phpliteadmin.inc

SRC_URI[md5sum] = "158f7424f89106e33d1a647c423a8dcb"
SRC_URI[sha256sum] = "7b83dac7194d0af08571768c69eefcbb4352980f4f813d97cefaf1bc0ead12fd"
