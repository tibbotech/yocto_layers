
require node-red-nodes.inc

S = "${WORKDIR}/npm"
