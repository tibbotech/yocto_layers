
require node-red-nodes.inc

S = "${WORKDIR}/npm"

LIC_FILES_CHKSUM = "file://LICENSE;md5=2c0cb74248cfa16e787ab1cf4c16e94e"
