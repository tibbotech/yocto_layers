
require node-red.inc

SRC_URI[pkg.sha256sum] = "22be0fa68ed1e4bac24aed89d943c67e8d8fb5a20bcd94ee6a304224b8ebe9bd"
