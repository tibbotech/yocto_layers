
SRC_URI = "git://github.com/joblib/joblib.git;branch=master;tag=${PV}"

SRC_URI[md5sum] = "182e6bc65681ea49a12775fdc86a8e24"
SRC_URI[sha256sum] = "0630eea4f5664c463f23fbf5dcfc54a2bc6168902719fa8e19daf033022786c8"

require python-joblib.inc
