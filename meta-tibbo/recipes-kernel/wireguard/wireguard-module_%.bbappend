
RRECOMMENDS:${PN} += "kernel-module-iptable-raw"
RRECOMMENDS:${PN} += "kernel-module-xt-addrtype"
RRECOMMENDS:${PN} += "kernel-module-xt-comment"
RRECOMMENDS:${PN} += "kernel-module-iptable-mangle"
RRECOMMENDS:${PN} += "kernel-module-xt-mark"
RRECOMMENDS:${PN} += "kernel-module-xt-connmark"
