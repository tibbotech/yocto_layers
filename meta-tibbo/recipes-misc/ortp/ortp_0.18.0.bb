require ortp.inc
DEPENDS = "glib-2.0 openssl"
PR = "${INC_PR}.1"

SRC_URI[md5sum] = "098e984f9325d9e2648bfd9863eed501"
SRC_URI[sha256sum] = "02c6d9dae910ce9f5af6f0c69d21b511f2744fdf4df6d1141b7329d0624ffdb1"
