require ortp.inc
DEPENDS = "glib-2.0 openssl"
PR = "${INC_PR}.1"

SRC_URI[md5sum] = "301d1e9e32d1ba5399bc82ceb11debf7"
SRC_URI[sha256sum] = "eb61a833ab3ad80978d7007411240f46e9b2d1034373b9d9dfaac88c1b6ec0af"
