#EXTRA_OECONF += " --disable-thread-safety"
