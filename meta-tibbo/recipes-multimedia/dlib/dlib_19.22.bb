require dlib.inc

PACKAGES = "${PN}-dev ${PN}-staticdev"

BBCLASSEXTEND = "native nativesdk"
