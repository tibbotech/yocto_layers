require ncnn.inc

SRCREV = "${AUTOREV}"
SRC_URI = "git://github.com/Tencent/ncnn.git;protocol=https;branch=master"

LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=8c8b5b19ef89ee9cfa47e768aa904935;rev={SRCREV}"
