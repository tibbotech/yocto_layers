SRCREV="513700f74787009241a11eda125284277f7dfc1c"

X_BR="support-2.11.1"

require pjproject.inc

SRC_URI[md5sum] = "c347a672679e7875ce572e18517884b2"
SRC_URI[sha256sum] = "2f5a1da1c174d845871c758bd80fbb580fca7799d3cfaa0d3c4e082b5161c7b4"
