DEPENDS_remove = "eudev"
DEPENDS_append = " udev"

PACKAGE_ARCH = "${MACHINE_ARCH}"
